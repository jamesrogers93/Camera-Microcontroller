# Keil uVision project Camera.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Camera
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx,USE_STM32746G_DISCO
  c include: Third_Party/FatFs/src/;Third_Party/FatFs/src/drivers;Third_Party/LibJPEG/include;../../../
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xf0000
  group Main
    ./: main.h main.c Camera.h Camera.c Data_Types.h Camera_View.h Camera_View.c Camera_Defines.h Data_types.c Touch_Handler.h Touch_Handler.c Camera_Photos.c Camera_Photos.h Error_Message.h Error_Message.c Camera_Globals.h Camera_Globals.c jdata_conf.c decode.c decode.h
  group Camera_Module
    ./: Camera_Module.c Camera_Module.h
  group SDCard_Module
    ./: SDCard_Module.c SDCard_Module.h
  group Bitmaps
    ./Icons/: Icon_Browse.c Icon_Camera.c Icon_Photos.c
  group Third_Party/FatFs/Core
    ./Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Third_Party/FatFs/Drivers
    ./Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Third_Party/LibJPEG
    ./Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatadst.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group JPEG_Module
    ./: Jpeg_Decode.c Jpeg_Decode.h Jpeg_RGB.h
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS:Keil RTX 4.81.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:LCD 1.1.1, Board Support:Drivers:SD 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:Touchscreen 1.1.1, Device:STM32Cube Framework:Classic 1.2.0, Device:STM32Cube HAL:Common 1.2.0, Device:STM32Cube HAL:Cortex 1.2.0, Device:STM32Cube HAL:DMA 1.2.0, Device:STM32Cube HAL:DMA2D 1.2.0, Device:STM32Cube HAL:GPIO 1.2.0, Device:STM32Cube HAL:I2C 1.2.0, Device:STM32Cube HAL:LTDC 1.2.0, Device:STM32Cube HAL:PWR 1.2.0, Device:STM32Cube HAL:RCC 1.2.0, Device:STM32Cube HAL:SD 1.2.0, Device:STM32Cube HAL:SDRAM 1.2.0, Device:STM32Cube HAL:UART 1.2.0, Device:Startup 1.2.0
